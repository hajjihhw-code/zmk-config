## config/boards/shields/barasch/Kconfig..defconfig
```kconfig
if SHIELD_BARSCH
config ZMK_KEYBOARD_NAME
default "Barsch Adaptive Controller
endif
```
